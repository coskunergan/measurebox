# Keil uVision project Project.uvproj, settings and files
target STM32L15xD_FLASH (ARM-ADS)
  device: STM32L152RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD
  c include: .\inc;..\..\STM32LIB\STM32L1xx_Board_Driver\inc;..\..\STM32LIB\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x6800
  memory RVCT10: RAM 0x20006800 size 0x800
  group System
    ./src/: system_stm32l1xx.c
    ./: startup_stm32l1xx_hd.s
  group User
    ./src/: main.c stm32l1xx_it.c pwr_mod.c common.c GL865.c int_eeprom.c rtc.c constants.c boot.c boot_ram.c flash_if.c extern_reg.c
  group Board
    ../../STM32LIB/STM32L1xx_Board_Driver/src/: stm32l1xx_Board_121016KGS00.c
  group StdPeriph
    ../../STM32LIB/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_pwr.c stm32l1xx_sdio.c stm32l1xx_syscfg.c stm32l1xx_i2c.c stm32l1xx_spi.c stm32l1xx_usart.c stm32l1xx_flash.c stm32l1xx_tim.c stm32l1xx_comp.c stm32l1xx_iwdg.c stm32l1xx_rtc.c stm32l1xx_flash_ramfunc.c
  group Notes
    ./src/: Readme.txt
